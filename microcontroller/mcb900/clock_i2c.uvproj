# Keil uVision project clock_i2c.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89LPC935 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM (0-0x1FF) CLOCK(12000000) MODP2
  output: workbench +hex
  group Basic
    ./: START900.A51 main.c io.c io.h bs.c bs.h
